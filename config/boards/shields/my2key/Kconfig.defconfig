## config/boards/shields/my2key/Kconfig.defconfig
```kconfig
if SHIELD_MY2KEY

config ZMK_KEYBOARD_NAME
    default "My2Key"

endif # SHIELD_MY2KEY
```
